<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_rate</value></param>
<param><key>value</key><value>64e3</value></param>
</block>
<block>
<key>sprite_peak_decimator_ff</key>
<param><key>id</key><value>sprite_peak_decimator_ff_0</value></param>
</block>
<block>
<key>sprite_correlator_cf</key>
<param><key>id</key><value>sprite_correlator_cf_0</value></param>
<param><key>prn_id</key><value>3</value></param>
</block>
<block>
<key>sprite_correlator_cf</key>
<param><key>id</key><value>sprite_correlator_cf_1</value></param>
<param><key>prn_id</key><value>2</value></param>
</block>
<block>
<key>sprite_sprite_decoder_f</key>
<param><key>id</key><value>sprite_sprite_decoder_f_0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>description</value></param>
<param><key>note</key><value>Demodulate a 64khz sampled binary data file</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zacman/Documents/GitHub/kicksat-groundstation/SpriteSample.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>sprite_peak_decimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sprite_peak_decimator_ff_0</source_block_id><sink_block_id>sprite_sprite_decoder_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>sprite_correlator_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>sprite_correlator_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
